File: hardware/name-blinker-2.sch (KiCad schematic (older format))
At the start: 40 parts, among them M1 MOUNTING-HOLE, M10 MOUNTING-HOLE, M12 MOUNTING-HOLE, M13 MOUNTING-HOLE, M2 MOUNTING-HOLE, M3 MOUNTING-HOLE, M4 MOUNTING-HOLE, M5 MOUNTING-HOLE, M6 MOUNTING-HOLE, M7 MOUNTING-HOLE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

Commit message: adjusted sch
Parts:
- added C10: 1nF, symbol C
- added C7: 10uF, Capacitors_SMD:c_elec_4x5.8, symbol C
- added C8, C9: 10uF, symbol C
- added L1: 1.5uH, symbol INDUCTOR
- added R13: 1M, symbol R
- added R14: 800K, symbol R
- added R15: 2M, symbol R
Connections:
- net GND: now also P1.8 (P8), U3.P$2 (GND2), U3.P$6 (PFM/PWM), U3.P$9 (GND9), C10.2, C7.2, C8.1, C9.1, R15.2; no longer P1.4 (P4)
- net SWCLK: now also P1.7 (P7); no longer P1.6 (P6)
- net SWDIO: now also P1.6 (P6); no longer P1.5 (P5)
- net UART_RX: now also P1.5 (P5); no longer P1.8 (P8)
- net UART_TX: now also P1.4 (P4); no longer P1.7 (P7)
- net VCC: now also U3.P$10 (ILIM0), U3.P$11 (EN), U3.P$12 (VIN), C7.1, R14.1; no longer C6.1, M12.1, P1.2 (P2), U2.P17 (VCC)
- net at U2.P12 (P0.31/AIN7): now also R14.2, R15.1
- net at U3.P$1 (L1): now also L1.2
- net at U3.P$3 (L2): now also L1.1
- net +3V3: now reaches U3.P$4 (VOUT)
- net +3V3: now also C6.1, M12.1, P1.2 (P2), U2.P17 (VCC), U3.P$5 (FB), C8.2, C9.2, R13.2
- net at U3.P$7 (SS): now also C10.1
- net at U3.P$8 (PG): now also R13.1
Other:
- moved on the sheet: BT1, BT2, C1, C2, C3, D1, D2, P1, P2, R1, R10, R11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

Commit message: add inductor
Parts:
- removed L1: 1.5uH, symbol INDUCTOR
- added L1: LPS3015, lps3015:LPS3015, symbol LPS3015
- C10: footprint (none) -> Capacitors_SMD:C_0805_HandSoldering
- C8, C9: footprint (none) -> Capacitors_SMD:c_elec_4x5.8
- R13, R14, R15: footprint (none) -> Resistors_SMD:R_0805_HandSoldering
Connections:
- net at U3.P$1 (L1): now also L1.2
- net at U3.P$3 (L2): now also L1.1
Changed lines of the file:
@@
 LIBS:BMD-300
 LIBS:tps63051
+LIBS:lps3015
 LIBS:name-blinker-2-cache
 EELAYER 25 0
@@
 $EndComp
 $Comp
-L GND #PWR7
+L GND #PWR01
 U 1 1 577B379D
 P 2450 1350
-F 0 "#PWR7" H 2450 1100 50  0001 C CNN
+F 0 "#PWR01" H 2450 1100 50  0001 C CNN
 F 1 "GND" H 2450 1200 50  0000 C CNN
 F 2 "" H 2450 1350 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR12
+L GND #PWR02
 U 1 1 577B3800
 P 5550 1050
-F 0 "#PWR12" H 5550 800 50  0001 C CNN
+F 0 "#PWR02" H 5550 800 50  0001 C CNN
 F 1 "GND" H 5550 900 50  0000 C CNN
 F 2 "" H 5550 1050 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR9
+L GND #PWR03
 U 1 1 577B3876
 P 3250 4350
-F 0 "#PWR9" H 3250 4100 50  0001 C CNN
+F 0 "#PWR03" H 3250 4100 50  0001 C CNN
 F 1 "GND" H 3250 4200 50  0000 C CNN
 F 2 "" H 3250 4350 50  0000 C CNN
@@
 $EndComp
 $Comp
-L +5V #PWR20
+L +5V #PWR04
 U 1 1 577B3A6B
 P 7400 900
-F 0 "#PWR20" H 7400 750 50  0001 C CNN
+F 0 "#PWR04" H 7400 750 50  0001 C CNN
 F 1 "+5V" H 7400 1040 50  0000 C CNN
 F 2 "" H 7400 900 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR16
+L GND #PWR05
 U 1 1 577B3A85
 P 7000 1950
-F 0 "#PWR16" H 7000 1700 50  0001 C CNN
+F 0 "#PWR05" H 7000 1700 50  0001 C CNN
 F 1 "GND" H 7000 1800 50  0000 C CNN
 F 2 "" H 7000 1950 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR22
+L GND #PWR06
 U 1 1 577B45AA
 P 8300 5650
-F 0 "#PWR22" H 8300 5400 50  0001 C CNN
+F 0 "#PWR06" H 8300 5400 50  0001 C CNN
 F 1 "GND" H 8300 5500 50  0000 C CNN
 F 2 "" H 8300 5650 50  0000 C CNN
@@
 $EndComp
 $Comp
-L +5V #PWR17
+L +5V #PWR07
 U 1 1 577B473E
 P 10000 4150
-F 0 "#PWR17" H 10000 4000 50  0001 C CNN
+F 0 "#PWR07" H 10000 4000 50  0001 C CNN
 F 1 "+5V" H 10000 4290 50  0000 C CNN
 F 2 "" H 10000 4150 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR19
+L GND #PWR08
 U 1 1 577B481A
 P 10350 5450
-F 0 "#PWR19" H 10350 5200 50  0001 C CNN
+F 0 "#PWR08" H 10350 5200 50  0001 C CNN
 F 1 "GND" H 10350 5300 50  0000 C CNN
 F 2 "" H 10350 5450 50  0000 C CNN
@@
 $EndComp
 $Comp
-L +5V #PWR13
+L +5V #PWR09
 U 1 1 577B45AC
 P 5850 4600
-F 0 "#PWR13" H 5850 4450 50  0001 C CNN
+F 0 "#PWR09" H 5850 4450 50  0001 C CNN
 F 1 "+5V" H 5850 4740 50  0000 C CNN
 F 2 "" H 5850 4600 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR14
+L GND #PWR010
 U 1 1 577B4629
 P 5850 5350
-F 0 "#PWR14" H 5850 5100 50  0001 C CNN
+F 0 "#PWR010" H 5850 5100 50  0001 C CNN
 F 1 "GND" H 5850 5200 50  0000 C CNN
 F 2 "" H 5850 5350 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR15
+L GND #PWR011
 U 1 1 577B4C69
 P 6250 6800
-F 0 "#PWR15" H 6250 6550 50  0001 C CNN
+F 0 "#PWR011" H 6250 6550 50  0001 C CNN
 F 1 "GND" H 6250 6650 50  0000 C CNN
 F 2 "" H 6250 6800 50  0000 C CNN
@@
 $EndComp
 $Comp
-L VCC #PWR21
+L VCC #PWR012
 U 1 1 577B56A5
 P 8300 4050
-F 0 "#PWR21" H 8300 3900 50  0001 C CNN
+F 0 "#PWR012" H 8300 3900 50  0001 C CNN
 F 1 "VCC" H 8300 4200 50  0000 C CNN
 F 2 "" H 8300 4050 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR23
+L GND #PWR013
 U 1 1 577B86AD
 P 10050 950
-F 0 "#PWR23" H 10050 700 50  0001 C CNN
+F 0 "#PWR013" H 10050 700 50  0001 C CNN
 F 1 "GND" H 10050 800 50  0000 C CNN
 F 2 "" H 10050 950 50  0000 C CNN
@@
 	1    0    0    -1
 $EndComp
-$Comp
-L INDUCTOR L1
-U 1 1 57805460
-P 1000 6300
-F 0 "L1" V 950 6300 50  0000 C CNN
-F 1 "1.5uH" V 1100 6300 50  0000 C CNN
-F 2 "" H 1000 6300 50  0000 C CNN
-F 3 "" H 1000 6300 50  0000 C CNN
-	1    1000 6300
-	-1   0    0    1
-$EndComp
 Wire Wire Line
 	1700 5850 1000 5850
@@
 	1200 6650 1000 6650
 Wire Wire Line
-	1000 6650 1000 6600
+	1000 6650 1000 6400
 Wire Wire Line
 	1000 5850 1000 6000
 $Comp
-L +3.3V #PWR8
+L +3.3V #PWR014
 U 1 1 57810FA7
 P 2750 3000
-F 0 "#PWR8" H 2750 2850 50  0001 C CNN
+F 0 "#PWR014" H 2750 2850 50  0001 C CNN
 F 1 "+3.3V" H 2750 3140 50  0000 C CNN
 F 2 "" H 2750 3000 50  0000 C CNN
@@
 $EndComp
 $Comp
-L +3.3V #PWR24
+L +3.3V #PWR015
 U 1 1 578115B5
 P 10050 1150
-F 0 "#PWR24" H 10050 1000 50  0001 C CNN
+F 0 "#PWR015" H 10050 1000 50  0001 C CNN
 F 1 "+3.3V" H 10050 1290 50  0000 C CNN
 F 2 "" H 10050 1150 50  0000 C CNN
@@
 $EndComp
 $Comp
-L +3.3V #PWR18
+L +3.3V #PWR016
 U 1 1 57811A79
 P 7150 1000
-F 0 "#PWR18" H 7150 850 50  0001 C CNN
+F 0 "#PWR016" H 7150 850 50  0001 C CNN
 F 1 "+3.3V" H 7150 1140 50  0000 C CNN
 F 2 "" H 7150 1000 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR3
+L GND #PWR017
 U 1 1 57812F9F
 P 1650 5600
-F 0 "#PWR3" H 1650 5350 50  0001 C CNN
+F 0 "#PWR017" H 1650 5350 50  0001 C CNN
 F 1 "GND" H 1650 5450 50  0000 C CNN
 F 2 "" H 1650 5600 50  0000 C CNN
@@
 	1650 5500 1650 5600
 $Comp
-L VCC #PWR2
+L VCC #PWR018
 U 1 1 57814261
 P 1650 5000
-F 0 "#PWR2" H 1650 4850 50  0001 C CNN
+F 0 "#PWR018" H 1650 4850 50  0001 C CNN
 F 1 "VCC" H 1650 5150 50  0000 C CNN
 F 2 "" H 1650 5000 50  0000 C CNN
@@
 F 0 "C10" H 3425 6800 50  0000 L CNN
 F 1 "1nF" H 3425 6600 50  0000 L CNN
-F 2 "" H 3438 6550 50  0000 C CNN
+F 2 "Capacitors_SMD:C_0805_HandSoldering" H 3438 6550 50  0001 C CNN
 F 3 "" H 3400 6700 50  0000 C CNN
 	1    3400 6700
@@
 	3400 6450 3400 6550
 $Comp
-L GND #PWR11
+L GND #PWR019
 U 1 1 57814D37
 P 3400 7050
-F 0 "#PWR11" H 3400 6800 50  0001 C CNN
+F 0 "#PWR019" H 3400 6800 50  0001 C CNN
 F 1 "GND" H 3400 6900 50  0000 C CNN
 F 2 "" H 3400 7050 50  0000 C CNN
@@
 F 0 "R13" V 1730 6850 50  0000 C CNN
 F 1 "1M" V 1650 6850 50  0000 C CNN
-F 2 "" V 1580 6850 50  0000 C CNN
+F 2 "Resistors_SMD:R_0805_HandSoldering" V 1580 6850 50  0001 C CNN
 F 3 "" H 1650 6850 50  0000 C CNN
 	1    1650 6850
@@
 	3200 6850 1800 6850
 $Comp
-L +3.3V #PWR1
+L +3.3V #PWR020
 U 1 1 57817BD5
 P 1450 7500
-F 0 "#PWR1" H 1450 7350 50  0001 C CNN
+F 0 "#PWR020" H 1450 7350 50  0001 C CNN
 F 1 "+3.3V" H 1450 7640 50  0000 C CNN
 F 2 "" H 1450 7500 50  0000 C CNN
@@
 F 0 "C8" H 1675 7150 50  0000 L CNN
 F 1 "10uF" H 1675 6950 50  0000 L CNN
-F 2 "" H 1688 6900 50  0000 C CNN
+F 2 "Capacitors_SMD:c_elec_4x5.8" H 1688 6900 50  0001 C CNN
 F 3 "" H 1650 7050 50  0000 C CNN
 	1    1650 7050
@@
 F 0 "C9" H 1675 7400 50  0000 L CNN
 F 1 "10uF" H 1675 7200 50  0000 L CNN
-F 2 "" H 1688 7150 50  0000 C CNN
+F 2 "Capacitors_SMD:c_elec_4x5.8" H 1688 7150 50  0001 C CNN
 F 3 "" H 1650 7300 50  0000 C CNN
 	1    1650 7300
@@
 $EndComp
 $Comp
-L GND #PWR6
+L GND #PWR021
 U 1 1 578189AC
 P 2050 7350
-F 0 "#PWR6" H 2050 7100 50  0001 C CNN
+F 0 "#PWR021" H 2050 7100 50  0001 C CNN
 F 1 "GND" H 2050 7200 50  0000 C CNN
 F 2 "" H 2050 7350 50  0000 C CNN
@@
 Connection ~ 1650 5550
 $Comp
-L GND #PWR10
+L GND #PWR022
 U 1 1 5781D354
 P 3400 6100
-F 0 "#PWR10" H 3400 5850 50  0001 C CNN
+F 0 "#PWR022" H 3400 5850 50  0001 C CNN
 F 1 "GND" H 3400 5950 50  0000 C CNN
 F 2 "" H 3400 6100 50  0000 C CNN
@@
 Connection ~ 2500 5100
 $Comp
-L VCC #PWR4
+L VCC #PWR023
 U 1 1 5783A258
 P 1950 1450
-F 0 "#PWR4" H 1950 1300 50  0001 C CNN
+F 0 "#PWR023" H 1950 1300 50  0001 C CNN
 F 1 "VCC" H 1950 1600 50  0000 C CNN
 F 2 "" H 1950 1450 50  0000 C CNN
@@
 $EndComp
 $Comp
-L GND #PWR5
+L GND #PWR024
 U 1 1 5783A2B0
 P 1950 2500
-F 0 "#PWR5" H 1950 2250 50  0001 C CNN
+F 0 "#PWR024" H 1950 2250 50  0001 C CNN
 F 1 "GND" H 1950 2350 50  0000 C CNN
 F 2 "" H 1950 2500 50  0000 C CNN
@@
 F 0 "R14" V 2030 1750 50  0000 C CNN
 F 1 "800K" V 1950 1750 50  0000 C CNN
-F 2 "" V 1880 1750 50  0000 C CNN
+F 2 "Resistors_SMD:R_0805_HandSoldering" V 1880 1750 50  0001 C CNN
 F 3 "" H 1950 1750 50  0000 C CNN
 	1    1950 1750
@@
 F 0 "R15" V 2030 2250 50  0000 C CNN
 F 1 "2M" V 1950 2250 50  0000 C CNN
-F 2 "" V 1880 2250 50  0000 C CNN
+F 2 "Resistors_SMD:R_0805_HandSoldering" V 1880 2250 50  0001 C CNN
 F 3 "" H 1950 2250 50  0000 C CNN
 	1    1950 2250
@@
 	7650 1700 7000 1700
 Connection ~ 7000 1700
+$Comp
+L LPS3015 L1
+U 1 1 578452CD
+P 1000 6200
+F 0 "L1" H 850 6350 45  0000 L BNN
+F 1 "LPS3015" H 850 6100 45  0000 L BNN
+F 2 "lps3015:LPS3015" H 1030 6350 20  0001 C CNN
+F 3 "" H 1000 6200 60  0000 C CNN
+	1    1000 6200
+	0    -1   -1   0
+$EndComp
 $EndSCHEMATC

Commit message: some adjustments
Parts:
- removed P1: CONN_01X08, Pin_Headers:Pin_Header_Angled_1x08, symbol CONN_01X08
- added P?: CONN_01X09, symbol CONN_01X09
Connections:
- net +3V3: now also P?.3 (P3)
- net +5V: now also P?.1 (P1)
- net GND: now also P?.4 (P4), P?.7 (P7)
- net SWCLK: now also P?.9 (P9)
- net SWDIO: now also P?.8 (P8)
- net UART_RX: now also P?.6 (P6)
- net UART_TX: now also P?.5 (P5)
- net VCC: now also P?.2 (P2)
Changed lines of the file:
@@
 L GND #PWR05
 U 1 1 577B3A85
-P 7000 1950
-F 0 "#PWR05" H 7000 1700 50  0001 C CNN
-F 1 "GND" H 7000 1800 50  0000 C CNN
-F 2 "" H 7000 1950 50  0000 C CNN
-F 3 "" H 7000 1950 50  0000 C CNN
-	1    7000 1950
+P 6950 2050
+F 0 "#PWR05" H 6950 1800 50  0001 C CNN
+F 1 "GND" H 6950 1900 50  0000 C CNN
+F 2 "" H 6950 2050 50  0000 C CNN
+F 3 "" H 6950 2050 50  0000 C CNN
+	1    6950 2050
 	1    0    0    -1
 $EndComp
@@
 Text GLabel 5000 1100 2    60   Input ~ 0
 SWCLK
+Text GLabel 7500 1700 0    60   Input ~ 0
+SWDIO
+Text GLabel 7500 1800 0    60   Input ~ 0
+SWCLK
+Text GLabel 7500 1400 0    60   Input ~ 0
+UART_TX
 Text GLabel 7500 1500 0    60   Input ~ 0
-SWDIO
-Text GLabel 7500 1600 0    60   Input ~ 0
-SWCLK
-Text GLabel 7500 1300 0    60   Input ~ 0
-UART_TX
-Text GLabel 7500 1400 0    60   Input ~ 0
 UART_RX
 Text GLabel 3850 3150 3    60   Input ~ 0
@@
 	2450 1300 2950 1300
 Wire Wire Line
-	2450 700  2450 1350
+	2450 700  2450 900
+Wire Wire Line
+	2450 900  2450 1000
+Wire Wire Line
+	2450 1000 2450 1100
+Wire Wire Line
+	2450 1100 2450 1200
+Wire Wire Line
+	2450 1200 2450 1300
+Wire Wire Line
+	2450 1300 2450 1350
 Wire Wire Line
 	2950 1200 2450 1200
@@
 	4950 900  5550 900
 Wire Wire Line
-	5550 700  5550 1050
+	5550 700  5550 900
+Wire Wire Line
+	5550 900  5550 1050
 Wire Wire Line
 	4950 700  5550 700
@@
 	4950 1100 5000 1100
 Wire Wire Line
+	7650 1700 7500 1700
+Wire Wire Line
+	7650 1800 7500 1800
+Wire Wire Line
+	7650 1400 7500 1400
+Wire Wire Line
 	7650 1500 7500 1500
 Wire Wire Line
-	7650 1600 7500 1600
-Wire Wire Line
-	7650 1300 7500 1300
-Wire Wire Line
-	7650 1400 7500 1400
-Wire Wire Line
-	7000 1200 7000 1950
-Wire Wire Line
 	3350 3100 3350 3200
 Wire Wire Line
 	3350 3200 2750 3200
 Wire Wire Line
-	2750 3000 2750 3300
+	2750 3000 2750 3200
+Wire Wire Line
+	2750 3200 2750 3300
 Wire Wire Line
 	3850 3100 3850 3150
@@
 	4050 3100 4050 3150
 Wire Wire Line
-	8300 4400 8300 5050
-Wire Wire Line
-	8300 5350 8300 5650
-Wire Wire Line
-	7400 4750 8800 4750
+	8300 4400 8300 4750
+Wire Wire Line
+	8300 4750 8300 5050
+Wire Wire Line
+	8300 5350 8300 5550
+Wire Wire Line
+	8300 5550 8300 5650
+Wire Wire Line
+	7400 4750 7900 4750
+Wire Wire Line
+	7900 4750 8300 4750
+Wire Wire Line
+	8300 4750 8800 4750
 Wire Wire Line
 	7400 4950 7500 4950
@@
 	7500 4950 7500 5550
 Wire Wire Line
-	7500 5550 8800 5550
+	7500 5550 7650 5550
+Wire Wire Line
+	7650 5550 7900 5550
+Wire Wire Line
+	7900 5550 8300 5550
+Wire Wire Line
+	8300 5550 8800 5550
 Connection ~ 8300 5550
 Wire Wire Line
@@
 	5850 5200 5850 5350
 Wire Wire Line
-	5850 4600 5850 4900
+	5850 4600 5850 4750
+Wire Wire Line
+	5850 4750 5850 4900
 Connection ~ 5850 4750
 Wire Wire Line
@@
 	6250 5200 6250 5100
 Wire Wire Line
-	6250 5600 6250 5850
+	6250 5600 6250 5700
+Wire Wire Line
+	6250 5700 6250 5850
 Wire Wire Line
 	6250 6250 6250 6150
@@
 	8800 5550 8800 5350
 Wire Wire Line
-	5850 4750 6600 4750
+	5850 4750 6250 4750
+Wire Wire Line
+	6250 4750 6600 4750
 Wire Wire Line
 	6450 5700 6250 5700
@@
 Wire Wire Line
 	4350 4200 4350 4100
-$Comp
-L CONN_01X08 P1
-U 1 1 577BE3FB
-P 7850 1350
-F 0 "P1" H 7850 1800 50  0000 C CNN
-F 1 "CONN_01X08" V 7950 1350 50  0000 C CNN
-F 2 "Pin_Headers:Pin_Header_Angled_1x08" H 7850 1350 50  0001 C CNN
-F 3 "" H 7850 1350 50  0000 C CNN
-	1    7850 1350
-	1    0    0    -1
-$EndComp
 Wire Wire Line
 	7650 1000 7400 1000
@@
 	7400 1000 7400 900
 Wire Wire Line
-	7650 1100 7150 1100
-Wire Wire Line
-	7150 1100 7150 1000
-Wire Wire Line
-	7650 1200 7000 1200
+	7050 1200 7650 1200
+Wire Wire Line
+	7050 1200 7050 1100
 $Comp
 L MOUNTING-HOLE M12
@@
 	4250 3650 4250 3100
 Wire Wire Line
-	2750 4300 4750 4300
+	2750 4300 3150 4300
+Wire Wire Line
+	3150 4300 3250 4300
+Wire Wire Line
+	3250 4300 3450 4300
+Wire Wire Line
+	3450 4300 4550 4300
+Wire Wire Line
+	4550 4300 4750 4300
 Wire Wire Line
 	3250 4300 3250 4350
@@
 L +3.3V #PWR016
 U 1 1 57811A79
-P 7150 1000
-F 0 "#PWR016" H 7150 850 50  0001 C CNN
-F 1 "+3.3V" H 7150 1140 50  0000 C CNN
-F 2 "" H 7150 1000 50  0000 C CNN
-F 3 "" H 7150 1000 50  0000 C CNN
-	1    7150 1000
+P 7050 1100
+F 0 "#PWR016" H 7050 950 50  0001 C CNN
+F 1 "+3.3V" H 7050 1240 50  0000 C CNN
+F 2 "" H 7050 1100 50  0000 C CNN
+F 3 "" H 7050 1100 50  0000 C CNN
+	1    7050 1100
 	1    0    0    -1
 $EndComp
@@
 	2300 5550 2300 5100
 Wire Wire Line
-	1650 5100 3300 5100
-Wire Wire Line
-	1650 5000 1650 5200
-Wire Wire Line
-	1650 5500 1650 5600
+	1650 5100 2300 5100
+Wire Wire Line
+	2300 5100 2500 5100
+Wire Wire Line
+	2500 5100 3300 5100
+Wire Wire Line
+	1650 5000 1650 5100
+Wire Wire Line
+	1650 5100 1650 5200
+Wire Wire Line
+	1650 5500 1650 5550
+Wire Wire Line
+	1650 5550 1650 5600
 $Comp
 L VCC #PWR018
@@
 	1700 6450 1450 6450
 Wire Wire Line
-	1450 6450 1450 7500
+	1450 6450 1450 6800
+Wire Wire Line
+	1450 6800 1450 6850
+Wire Wire Line
+	1450 6850 1450 7050
+Wire Wire Line
+	1450 7050 1450 7300
+Wire Wire Line
+	1450 7300 1450 7500
 Wire Wire Line
 	1500 6850 1450 6850
@@
 	1800 7050 2050 7050
 Wire Wire Line
-	2050 7050 2050 7350
-Wire Wire Line
-	1800 7300 2500 7300
+	2050 7050 2050 7300
+Wire Wire Line
+	2050 7300 2050 7350
+Wire Wire Line
+	1800 7300 2050 7300
+Wire Wire Line
+	2050 7300 2500 7300
 Connection ~ 2050 7300
 Wire Wire Line
@@
 $EndComp
 Wire Wire Line
-	1950 1900 1950 2100
+	1950 1900 1950 2000
+Wire Wire Line
+	1950 2000 1950 2100
 Connection ~ 1950 2000
 Wire Wire Line
@@
 Wire Wire Line
 	2950 2000 1950 2000
-Wire Wire Line
-	7650 1700 7000 1700
-Connection ~ 7000 1700
 $Comp
 L LPS3015 L1
@@
 	0    -1   -1   0
 $EndComp
+$Comp
+L VCC #PWR025
+U 1 1 578150D2
+P 7250 950
+F 0 "#PWR025" H 7250 800 50  0001 C CNN
+F 1 "VCC" H 7250 1100 50  0000 C CNN
+F 2 "" H 7250 950 50  0000 C CNN
+F 3 "" H 7250 950 50  0000 C CNN
+	1    7250 950
+	1    0    0    -1
+$EndComp
+Wire Wire Line
+	7250 950  7250 1100
+Wire Wire Line
+	7250 1100 7650 1100
+Wire Wire Line
+	7650 1300 6950 1300
+Wire Wire Line
+	6950 1300 6950 1600
+Wire Wire Line
+	6950 1600 6950 1900
+Wire Wire Line
+	6950 1900 6950 2050
+Wire Wire Line
+	7650 1600 6950 1600
+Connection ~ 6950 1600
+$Comp
+L CONN_01X09 P?
+U 1 1 57815D7E
+P 7850 1400
+F 0 "P?" H 7850 1900 50  0000 C CNN
+F 1 "CONN_01X09" V 7950 1400 50  0000 C CNN
+F 2 "" H 7850 1400 50  0000 C CNN
+F 3 "" H 7850 1400 50  0000 C CNN
+	1    7850 1400
+	1    0    0    -1
+$EndComp
 $EndSCHEMATC
