# Repository yeokm1/name-blinker-2

## KiCad design hardware/name-blinker-2.kicad_pcb

Board: 2 copper layers, 70.0 x 50.0 mm, 56 parts (0 on the bottom side), 38 nets.

Parts:
BT1: LIR2450; CR2450_KEYSTONE
BT2: JST; Molex_MicroLatch-53254-0270_02x2.00mm_Angled
C1, C2: 4.7uF; C_0805_HandSoldering
C3, C6: 0.1uF; C_0805_HandSoldering
C7, C8, C9: 10uF; c_elec_4x5.8
C10: 1nF; C_0805_HandSoldering
D1: LED_Red; LED_0805
D2: LED_Green; LED_0805
D3, D4, D5, D6, D7, D8, D9, D10, D11: LED; LED_0805
L1: LPS3015
M0, M2, M3, M4, M5, M11, M12, M13, M17, M19, M28, M33: MOUNTING-HOLE; MountingHole_2.5mm_Pad
P1: CONN_01X09; Pin_Header_Angled_1x09
P2: USB_OTG; USB_Micro-B
R1, R2, R3, R4, R5, R6, R7, R8, R9: 2.6K; R_0805_HandSoldering
R10: 1.5K; R_0805_HandSoldering
R11: 600; R_0805_HandSoldering
R12: 20K; R_0805_HandSoldering
R13: 1M; R_0805_HandSoldering
R14: 800K; R_0805_HandSoldering
R15: 2M; R_0805_HandSoldering
SW1: SW_PUSH; SW_SPST_B3S-1000
SW2: SMD-TOGGLE-SWITCH-2CH_2X3P-7X3.5MM_; SW6-2.54-SMD-7.0X3.5X1.5MM
U1: MCP73831; SOT-23-5
U2: BMD-300; BMD-300-BMD-300
U3: TPS63051

Connections:
+3V3: C6.1, C8.2, C9.2, M33.1, P1.7, R13.2, U2.P17, U3.P$4, U3.P$5
+5V: C1.1, P1.9, P2.1, R10.1, U1.4
GND: BT1.2, BT2.2, C1.2, C2.2, C3.2, C6.2, C7.2, C8.1, C9.1, C10.2, D2.1, D3.1, D4.1, D5.1, D6.1, D7.1, D8.1, D9.1, D10.1, D11.1, M0.1, P1.3, P1.6, P2.5, R12.2, R15.2, SW1.2, U1.2, U2.P1, U2.P2, U2.P3, U2.P4, U2.P5, U2.P16, U2.P18, U2.P29, U2.P30, U2.P45, U2.P46, U2.P47, U3.P$2, U3.P$6, U3.P$9
In0: M28.1, SW1.1, U2.P9
unnamed: BT1.1, BT2.1, C2.1, SW2.COM2, U1.3
unnamed: C3.1, P2.6
unnamed: C10.1, U3.P$7
unnamed: D1.1, R11.1, U1.1
unnamed: D1.2, R10.2
unnamed: D2.2, R11.2
unnamed: D3.2, M2.1, R1.1
unnamed: D4.2, M3.1, R2.1
unnamed: D5.2, M4.1, R3.1
unnamed: D6.2, M5.1, R4.1
unnamed: D7.2, M11.1, R5.1
unnamed: D8.2, M12.1, R6.1
unnamed: D9.2, M13.1, R7.1
unnamed: D10.2, M17.1, R8.1
unnamed: D11.2, M19.1, R9.1
unnamed: L1.1, U3.P$3
unnamed: L1.2, U3.P$1
unnamed: R12.1, U1.5
unnamed: R13.1, U3.P$8
unnamed: R14.2, R15.1, U2.P11
Out0: R1.2, U2.P15
Out1: R2.2, U2.P19
Out2: R3.2, U2.P20
Out3: R4.2, U2.P21
Out4: R5.2, U2.P27
Out5: R6.2, U2.P28
Out6: R7.2, U2.P31
Out7: R8.2, U2.P35
Out8: R9.2, U2.P37
SWCLK: P1.1, U2.P43
SWDIO: P1.2, U2.P44
UART_RX: P1.4, U2.P24
UART_TX: P1.5, U2.P22
VCC: C7.1, P1.8, R14.1, SW2.CH2B, U3.P$10, U3.P$11, U3.P$12

## Commit log

2016-07-09 adjusted sch
2016-07-09 add inductor
2016-07-09 add lps 3015 lib
2016-07-09 some adjustments
2016-07-09 charging circuit side
2016-07-09 connected all wires
2016-07-10 connected everything
2016-07-10 silkscreen stuff
2016-07-10 all lines connected
2016-07-10 miter corners
2016-07-10 final changes to rev 1
2016-07-10 revision 1 gerber
2016-07-10 gerber settings
2016-07-15 adjusted rev 1 gerber
2016-07-22 rev2, adjust grounding
2016-07-22 rev 2 gerber
2016-07-22 corrected bug in charge complete led. move out 2.6K reference
2016-07-22 change mounting hole reference name to be in line with connected NRF pins
2016-07-22 update rev2 gerber
2016-07-24 replace ignore
